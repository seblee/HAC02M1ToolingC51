# Keil uVision project T5L_PRJ.uvproj, settings and files
target T5L51 (MCS-51)
  device: T5 DWIN
  cpu: IRAM(0-0xFF) CLOCK(24000000) MODC2 PMW DPC BSE MDU_R515
  output: T5L51 +hex
  AfterMake: ..\AfterBuildRun.bat
  c flags: Optimize=3
  c include: ..\USER;..\GUI_APP;..\FUNC_HANDLER;..\HARDWARE
  link misc: REMOVEUNUSED
  group USER
    ./: STARTUP_M5.A51 main.c sys.c
  group GUI_APP
    ../GUI_APP/: dgus.c ui.c curve.c alarm.c ChineseCharacter.c
  group HARDWARE
    ../HARDWARE/: uart.c rtc.c timer.c norflash.c
    ../FUNC_HANDLER/: T5L_lib.c
  group FUNC_HANDLER
    ../FUNC_HANDLER/: crc16.c modbus.c control.c
